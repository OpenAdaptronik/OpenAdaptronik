# Repository OpenAdaptronik/OpenAdaptronik

File README.md:

# OpenAdaptronik
This repository represents all (currently) public available data from the BMBF project "OpenAdaptronic".
See www.openadaptronik.de for further information.

## EAGLE design Used Hardware Data/Sensors Data and measurements/SparkFun Triple/ADXL335_Breakout.brd

Board: 2 copper layers, 17.8 x 15.2 mm, 12 parts (2 on the bottom side), 6 nets.

Parts:
C1, C2, C3, C4: 0.1uF; 0603-CAP
SL1: 1X06
U$1, U$3: FIDUCIAL1X2; FIDUCIAL-1X2
U$4: ADXL335-PATRICK""; ADXL335-P
U$5: OSHW-LOGO-S
U$6, U$7: STAND-OFF-TIGHT
U$8: SFE_LOGO_NAME_.1

Connections:
GND: C1.1, C2.2, C3.2, C4.2, SL1.5, U$4.3, U$4.5, U$4.6, U$4.7
ST: SL1.1, U$4.2
VCC: C2.1, SL1.6, U$4.14, U$4.15
XOUT: C4.1, SL1.4, U$4.12
YOUT: C3.1, SL1.3, U$4.10
ZOUT: C1.2, SL1.2, U$4.8

## Commit log

2016-06-28 Ein Beispiel für Scilab Batch hinzugefügt
    Ein Beispiel für Scilab Batch hinzugefügt
2017-11-29 PyTESS hinzugefügt
    PyTESS ist eine implementierung des Matlabprogramms TESS von Lennard
    Jäger in der Sprache Python.
2017-11-29 Kleine änderungen, damit der code auch durchläuft.
2017-11-29 Weitere inkrementelle Anpassungen
2017-11-30 Inkrementelle Aenderungen, um unterschiedliches Verhlaten von TESS und PyTESS zu beheben.
2017-12-06 reworked the code to gain insight where differences are coming from.
2018-02-26 Filechanges 0_1
2018-02-26 :tada: Added .gitattributes & .gitignore files
2018-02-27 A DIY open source vibration data logger
2018-03-02 Design of the sensor housing (bottom part)
2018-03-02 Deisgn files and Arduino software
2018-03-02 Revert "Design of the sensor housing (bottom part)"
    This reverts commit 3bd735e79b1e1f53e31ca6430d412056d37f199e.
2018-03-02 Sensor enclosure design file
2018-03-02 Sensor enclosure sealing design file
2018-03-02 Wiring schematic
2018-03-02 Arduino sketch and libraries
2018-04-06 Added content
    Added Sensor data, Sensor Housing CAD files and Actioncam mounting files.
2018-04-13 DIY Actuator added
    All files needed to build linear actuator, Version 1 and 2
2018-10-19 Cleanup
2018-11-19 Initial version
2018-11-19 Brief documentation
2018-11-19 Rename Py_RandomDecrement.md to README.md
2018-11-23 Some bugs fixed.
    "Save plot" removed, since exporting plots is part of pyqtgraph

Notices in the files:
parts and their libraries:
SparkFun-Aesthetics: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
